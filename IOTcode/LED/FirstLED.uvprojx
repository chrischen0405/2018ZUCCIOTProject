# Keil uVision project FirstLED.uvprojx, settings and files
target FirstLED (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FirstLED
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: .\SRC;..\..\Libraries\STM32F4xx_LIB\inc;..\..\Libraries\STM32F4xx_LIB\CMSIS;..\..\Common;..\..\Libraries\delay;..\..\Libraries\USART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group LIB
    ../../Libraries/STM32F4xx_LIB/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c misc.c
    ../../Libraries/STM32F4xx_LIB/CMSIS/: system_stm32f4xx.c startup_stm32f401xx.s
  group hardware
    ../../Common/: Config.c
    ../../Libraries/delay/: delay.c
    ../../Libraries/USART/: USART.c
  group user
    ./SRC/: Hal_led.c main.c
software components: CMSIS:CORE 4.1.0
