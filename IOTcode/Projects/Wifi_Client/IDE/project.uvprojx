# Keil uVision project project.uvprojx, settings and files
target project (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: ..\SRC;..\..\..\Libraries\STM32F4xx_LIB\inc;..\..\..\Libraries\STM32F4xx_LIB\CMSIS;..\..\..\Common;..\..\..\Libraries\delay;..\..\..\Libraries\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group STM32F4xx_LIB
    ../../../Libraries/STM32F4xx_LIB/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c misc.c stm32f4xx_tim.c stm32f4xx_it.c stm32f4xx_spi.c
    ../../../Libraries/STM32F4xx_LIB/CMSIS/: system_stm32f4xx.c startup_stm32f401xx.s
  group hardware
    ../../../Libraries/delay/: delay.c
    ../../../Common/: Config.c
  group user
    ../SRC/: main.c hal_uart.c em380c_hal.c EMSP.c EMSP_API.c hal_rgb_led.c hal_temp_hum.c hal_infrared.c hal_motor.c Hal_led.c AsciiLib.c Hal_OLED.c
software components: CMSIS:CORE 4.1.0
